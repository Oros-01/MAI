#include <iostream>
#include <cstring>



using namespace std;
/*
1) Что такое size_t и зачем присваивать n = strlen(words)?

size_t — это целочисленный тип без знака (unsigned), который используется для представления размеров и индексов объектов в памяти (длина массива, возвращаемое sizeof, результат strlen и т.п.). Он гарантировано достаточен, чтобы вместить размер самой большой возможной области памяти на данной платформе.
strlen возвращает значение типа size_t. Поэтому хорошо хранить длину именно в size_t n, чтобы не смешивать signed/unsigned и не получать предупреждений компилятора.

Почему n = strlen(words) полезно (а не вызывать strlen каждый раз в заголовке цикла):

strlen — это O(n) операция: она проходит по строке до '\0', считая символы. Если ты вызываешь strlen(words) в условии цикла на каждой итерации — ты каждый раз заново пересчитываешь длину. Это лишняя трата времени.

Читаемость: n — одно место, где хранится длина. Если позже строка меняется, можно явно обновить n (или заново вызвать strlen там, где нужно).

Типовая безопасность: size_t n = strlen(words); делает типы согласованными (нет неявных преобразований).
*/


void sort_up(char* words){
    int n = strlen(words);// создаем массив
    /*  
    открываем первый цикл по words и останавливаясь на первой букве "b"
    открываем второй цикл по words и пока в первом стоим на первой букве "b" здесь открываем аналогичный
    цикл и у нас получается в из первой b открывается новый banana и в нём проходятся по всем буквам,
    потом мы попадаем во вторую a(из главного цикла) и также проходимся по всем буквам.
    ! Во время этого прохождения мы каждый раз сравниваем соседние буквы и если левая больше, то мы переставляем их местами
    */
    for (int i = 0; i < n; i=i+1){ 
        for (int j = i; j < n-1; j=j+1){
            if (words[j] > words[j+1]) {
                swap (words[j], words[j+1]);
            }
        }
    }
}

void sort_down(char* words){
    int n = strlen(words);// создаем массив
    /*  
    открываем первый цикл по words и останавливаясь на первой букве "b"
    открываем второй цикл по words и пока в первом стоим на первой букве "b" здесь открываем аналогичный
    цикл и у нас получается в из первой b открывается новый banana и в нём проходятся по всем буквам,
    потом мы попадаем во вторую a(из главного цикла) и также проходимся по всем буквам.
    ! Во время этого прохождения мы каждый раз сравниваем соседние буквы и если левая больше, то мы переставляем их местами
    */
    for (int i = 0; i < n; i=i+1){ 
        for (int j = i; j < n-1; j=j+1){
            if (words[j] < words[j+1]) {
                swap (words[j], words[j+1]);
            }
        }
    }
}

void make_lower(char* word) { //Звёздочка для работы с оригиналом(лезем сразу в ячейку памяти и меняем значение), переменная word хранит адрес(указатель)
    for (int i = 0; word[i] != '\0' ; i = i+1) { // '\0' - это символ конца строки("Red" хранится как: 'R' 'e' 'd' '\0')
        //Если буква большая
        if (word[i] >= 'A' && word[i] <= 'Z') { //то есть если у нас буква в диапазоне от A-Z(65-90), то прибавляем к ней 32, чтобы попасть на диапазон малых букв
            word[i] = word[i] + 32; // Чтобы изменить кодировку на малые, по таблице кодировки ASCII
        }
    }
}

void remove_space(char* space_word){
    int j = 0;
    for (int i = 0; i < strlen(space_word); i=i+1){ 
        if (space_word[i] != ' '){ // Если НЕ пробел, то входим в if
            swap (space_word[j], space_word[i]); //
            j = j+1; // Прибавляем каждый раз, когда у нас НЕ пробел
            // В итоге i всегда движется вперед, а j движется вперед только если нет пробелов и при замене j на i
            // то есть у нас в j перекидываются только НЕпробельные символы и только после этого мы делаем j+1
            // В итоге у нас пустота которая щас в j заменяется на символ и j идёт дальше
            // после цикла все пробелы в конце
        }
    }
    space_word[j] = '\0'; // уже обновлённый j(после последнего НЕпробельного) заменяется на конец строки
}